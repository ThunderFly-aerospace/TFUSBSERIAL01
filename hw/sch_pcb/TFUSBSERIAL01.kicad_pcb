# Repository ThunderFly-aerospace/TFUSBSERIAL01

File README.md:

# TFUSBSERIAL01 - USB-C to serial converter with Pixhawk telemetry JST-GH connector

The converter is designed to service operations on UAVs. It respects the [Pixhawk DS-009](https://github.com/pixhawk/Pixhawk-Standards/blob/master/DS-009%20Pixhawk%20Connector%20Standard.pdf) connector standard.

## Key features
 
  * Could be connected to both peripheral or FMUs
  * The FMU and peripheral connectors are separated, therefore there is no need for a special RX/TX cross-cable
  * Could be used for sniffing serial communication on telemetry links between autopilot and its peripheral (Both connectors could be used at once)
  * Supports hardware flow control
  * The power delivered from USB is protected from excess current possibly drawn by peripheral or FMU
  * The accidental power from FMU to USB is protected by reverse diode

### Where to Get It?
TFUSBSERIAL can be bought directly from ThunderFly via [email contact](https://www.thunderfly.cz/contact-us.html). The email can also be used if there are specific requirements for custom modifications and accessories (cables for example) or if the product will be inquired in significant quantities.

## KiCad design hw/sch_pcb/TFUSBSERIAL01.kicad_pcb

Parts:
C1: 10nF; C_0603_1608Metric
C2, C4, C5: 100nF; C_0603_1608Metric
C3: 10uF; C_0603_1608Metric
D1: SRL23; D_SOD-323_HandSoldering
D2: RED; LED_0603_1608Metric
D3, D4: GREEN; LED_0603_1608Metric
F1: 350mA; Fuse_0805_2012Metric
FB1: BLM21PG300SN1D; L_0805_2012Metric
FID1, FID2: Fiducial; Fiducial_0.5mm_Mask1mm
J1: USBC_USB4105-GF-A; USBC GCT_USB4105-GF-A
J2, J3: SM06B-GHS-TB; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
JP1: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_Pad1.0x1.5mm_NumberLabels
M1, M2, M3, M4, M5, M6: HOLE_TF; dira_3mm
R1, R2: 5k1; R_0603_1608Metric
R3: 4k7; R_0603_1608Metric
R4: 10k; R_0603_1608Metric
R5: 287R; R_0603_1608Metric
R6, R7: 130R; R_0603_1608Metric
R8, R9, R10, R11: 100R; R_0603_1608Metric
TP1: #DTR; TestPoint_Pad_D1.0mm
TP2: #DSR; TestPoint_Pad_D1.0mm
TP3: #DCD; TestPoint_Pad_D1.0mm
TP4: #RI; TestPoint_Pad_D1.0mm
U1: USBLC6-2SC6; SOT-23-6
U2: FT231XQ; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm

Connections:
+5V: C3.1, C4.1, D2.2 (A), D3.2 (A), D4.2 (A), F1.1, FB1.2, U2.12 (VCC)
/#CTS: J2.4, J3.5, R11.2
/#DTR: JP1.1 (A), TP1.1 (1_1), U2.18 (~DTR)
/#RTS: J3.4, JP1.3 (B), R10.2
/D+: J1.A6 (D+), J1.B6 (D+), U1.4 (I/O2)
/D-: J1.A7 (D-), J1.B7 (D-), U1.6 (I/O1)
/DM: U1.1 (I/O1), U2.9 (USBDM)
/DP: U1.3 (I/O2), U2.8 (USBDP)
/RXD: J2.3, J3.2, R9.2
/RXLED/CBUS1: R5.2, U2.14 (CBUS1)
/TXD: J2.2, J3.3, R8.2
/TXLED/CBUS2: R6.2, U2.7 (CBUS2)
/VBUS: C1.1, FB1.1, J1.A4/B9 (VBUS), J1.B4/A9 (VBUS), R3.1, U1.5 (VBUS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.A1/B12 (GND), J1.B1/A12 (GND), J1.G1 (SHIELD), J1.G2 (SHIELD), J1.G3 (SHIELD), J1.G4 (SHIELD), J2.6, J2.MP, J3.6, J3.MP, R1.2, R2.2, R4.2, R7.2, U1.2 (GND), U2.3 (GND), U2.13 (GND), U2.21 (GND)
unnamed: D1.2 (A), F1.2, J2.1
unnamed: D1.1 (K), J3.1
unnamed: D2.1 (K), R5.1
unnamed: D3.1 (K), R6.1
unnamed: D4.1 (K), R7.1
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J2.5, JP1.2 (C)
unnamed: C2.1, C5.1, U2.10 (3V3OUT), U2.20 (VCCIO)
unnamed: R9.1, U2.1 (RXD)
unnamed: R8.1, U2.17 (TXD)
unnamed: R11.1, U2.6 (~CTS)
unnamed: TP3.1 (1_1), U2.5 (~DCD)
unnamed: TP2.1 (1_1), U2.4 (~DSR)
unnamed: R3.2, R4.1, U2.11 (~RESET)
unnamed: TP4.1 (1_1), U2.2 (~RI)
unnamed: R10.1, U2.19 (~RTS)

Notes on the sheet:
to Peripheral
to FMU

Board: 2 copper layers, 30.0 x 30.0 mm, 40 parts (29 on the bottom side), 31 nets.

File hw/cam_profi/assembly/TFUSBSERIAL01-bom.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,ust_id
1,Unpolarized capacitor,C,C1,10nF,C_0603_1608Metric,1,~,5c70984812875079b91f8bef
2,Unpolarized capacitor,C,C2C4C5,100nF,C_0603_1608Metric,3,~,5c70984812875079b91f8bf2
3,Unpolarized capacitor,C,C3,10uF,C_0603_1608Metric,1,~,5c70984812875079b91f8bf5
4,Light emitting diode,LED,D3D4,GREEN,LED_0603_1608Metric,2,~,60d582331287500165f859d0
5,Light emitting diode,LED,D2,RED,LED_0603_1608Metric,1,~,60d581db1287500165f859a2
6,Diode,D,D1,SRL23,D_SOD-323_HandSoldering,1,https://www.tme.eu/Document/039d7772a3e1de850ecf12d397e62c7b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,651003fd462c6d9e72054b2f
7,"Resettable fuse, polymeric positive temperature coefficient",Polyfuse,F1,350mA,Fuse_0805_2012Metric,1,~,650b8191462c6d9e7205477b
8,"Ferrite bead, small symbol",FerriteBead_Small,FB1,BLM21PG300SN1D,L_0805_2012Metric,1,~,5c70984412875079b91f87fd
9,1x07 2.54 mm pitch header,SM06B-GHS-TB,J2J3,SM06B-GHS-TB,JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal,2,,5fa0f70212875025b3977932
10,USB 2.0-only Type-C Receptacle connector,USBC_USB4105-GF-A,J1,USBC_USB4105-GF-A,USBC GCT_USB4105-GF-A,1,,5fa0f94612875025b397795e
11,Resistor,R,R8R9R10R11,100R,R_0603_1608Metric,4,~,5c70984512875079b91f8956
12,Resistor,R,R6R7,130R,R_0603_1608Metric,2,~,5cd08b17128750448e4542b1
13,Resistor,R,R5,287R,R_0603_1608Metric,1,~,651a975c462c6d9e7205504d
14,Resistor,R,R3,4k7,R_0603_1608Metric,1,~,5c70984512875079b91f8960
15,Resistor,R,R1R2,5k1,R_0603_1608Metric,2,~,628d1404dc56076e9a223650
16,Resistor,R,R4,10k,R_0603_1608Metric,1,~,5c70984512875079b91f8962
17,"Full Speed USB to Full Handshake UART, QFN-20",FT231XQ,U2,FT231XQ,QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm,1,https://www.ftdichip.com/Support/Documents/DataSheets/ICs/DS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,605d7fe0128750769e769adb
18,"Very low capacitance ESD protection diode, 2 data-line, SOT-23-6",USBLC6-2SC6,U1,USBLC6-2SC6,SOT-23-6,1,https://www.st.com/resource/en/datasheet/usblc6-2.pdf,5e82e0691287502a334a778c

## Commit log (part)

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2021-05-19 Schema
2021-05-19 Edit
2021-05-21 Edit PCB
2021-05-27 Edit SCH and PCB
2023-08-03 Procisteni repozitare
2023-08-03 add actions
2023-08-03 Update actions products
2023-08-03 Edit schema
2023-08-03 Update README.md
    add a list of key features.
2023-08-03 Change fuse schematics symbol to polyfuse Solve some offgrid placed componets Rename Device connector to peripheral connector.
2023-09-20 usb serial
2023-09-20 update silkscreen
2023-09-20 update ust_id
2023-09-22 layout updates
2023-09-23 Update workflow files
2023-09-24 Kontrola a upravy pred vyrobou.
2023-09-26 Aisler custom bridges
2023-09-29 exclude mechanical components from BOM.
2023-10-02 Edit UST_ID
2023-10-04 Edit B.Fab
2023-10-05 Describe self-test feature in the readme.
2024-04-22 Update photos of the designs.
2024-04-23 Add PCB dimensions.
2025-06-29 Update links in listing.
2025-12-25 Update title block. Update project to KiCADv9.
2025-12-25 Fix submodule branch.
2026-06-07 Fixing #4 WIP.
